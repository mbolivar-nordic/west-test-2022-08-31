## west.yml
```yaml
manifest:
  projects:
    - name: zephyr
      revision: v3.0.0
      url: https://github.com/Altronix/zephyr
```
